# Keil uVision project stc-vibrate.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: stc-vibrate +hex
  link misc: REMOVEUNUSED
  group app
    ./usr/: main.c gpio_interrupt.c ebf_control.c ntc_sampling.c io_status.c
  group library
    ./library/: STC32G_GPIO.c STC32G_Delay.c STC32G_UART.c STC32G_UART_Isr.c STC32G_NVIC.c STC32G_ADC.c STC32G_PWM.c
